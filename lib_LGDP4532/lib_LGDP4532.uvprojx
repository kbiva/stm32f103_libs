# Keil uVision project lib_LGDP4532.uvprojx, settings and files
target lib_LGDP4532 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lib_LGDP4532 (library)
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: .\inc;..\lib_STM32F10x_StdPeriph\inc;..\lib_delay\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: LGDP4532.h colors.h font6x8.h font8x8.h font8x14.h
  group src
    ./src/: LGDP4532.c
