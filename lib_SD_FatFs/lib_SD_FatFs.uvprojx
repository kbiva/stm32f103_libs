# Keil uVision project lib_SD_FatFs.uvprojx, settings and files
target lib_SD_FatFs (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lib_SD_FatFs (library)
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\lib_STM32F10x_StdPeriph\inc;..\lib_rtc\inc;..\lib_FatFs\inc;..\lib_SD_SDIO\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: diskio.h
  group src
    ./src/: diskio.c
