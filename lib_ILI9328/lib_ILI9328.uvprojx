# Keil uVision project lib_ILI9328.uvprojx, settings and files
target lib_ILI9328 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib_ILI9328 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .\inc;..\lib_delay\inc;..\lib_STM32F10x_StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: colors.h ILI9328.h
  group src
    ./src/: ILI9328.c
