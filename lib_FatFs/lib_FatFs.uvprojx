# Keil uVision project lib_FatFs.uvprojx, settings and files
target lib_FatFs (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lib_FatFs (library)
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\lib_SD_FatFs\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: ff.h ffconf.h integer.h
  group src
    ./src/: ff.c
