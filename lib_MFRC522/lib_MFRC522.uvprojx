# Keil uVision project lib_MFRC522.uvprojx, settings and files
target lib_MFRC522 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib_MFRC522 (library)
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\inc;..\lib_STM32F10x_StdPeriph\inc;..\lib_delay\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: mfrc522.h
  group src
    ./src/: mfrc522.c
