# Keil uVision project lib_SD_SDIO.uvprojx, settings and files
target lib_SD_SDIO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lib_SD_SDIO (library)
  c flags: Optim=1 OneElfS=1
  c include: .\inc;..\lib_STM32F10x_StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: sd_card_func.h stm3210e_eval_sdio_sd.h
  group src
    ./src/: sd_card_func.c stm3210e_eval_sdio_sd.c
