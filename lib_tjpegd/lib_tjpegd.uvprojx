# Keil uVision project lib_tjpegd.uvprojx, settings and files
target lib_tjpegd (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib_tjpegd (library)
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: tjpgd.c
  group inc
    ./inc/: tjpgd.h integer.h
